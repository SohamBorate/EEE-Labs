# Keil uVision project Week-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ED2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: Week-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: src-1.asm src-2.asm src-3.asm src-4.asm src-5-a.asm src-5-b.asm
