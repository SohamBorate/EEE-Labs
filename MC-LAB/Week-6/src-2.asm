ORG 0000H

MOV R4, #80H // 2.5 VOLTS

REPEAT: MOV R2, #16
MOV R3, #00
MOV DPTR, #SINEUPHALF

// up half

LOOP1: MOV A, R3
MOVC A, @A+DPTR
ADD A, R4
MOV P1, A
INC R3
ACALL DELAY
DJNZ R2, LOOP1

// down half

DEC R3
DEC R3
MOV R2, #15

LOOP2: MOV A, R3
MOVC A, @A+DPTR
ADD A, R4
MOV P1, A
DEC R3
ACALL DELAY
DJNZ R2, LOOP2

///////////

MOV R2, #16
MOV R3, #00
MOV DPTR, #SINEUPHALF

// down half

LOOP3: MOV A, R3
MOVC A, @A+DPTR
CLR C
MOV R5, A
MOV A, R4
SUBB A, R5
MOV P1, A
INC R3
ACALL DELAY
DJNZ R2, LOOP3

// up half

DEC R3
DEC R3
MOV R2, #15

LOOP4: MOV A, R3
MOVC A, @A+DPTR
CLR C
MOV R5, A
MOV A, R4
SUBB A, R5
MOV P1, A
DEC R3
ACALL DELAY
DJNZ R2, LOOP4

SJMP REPEAT

DELAY: MOV R7, #50
LOOPDELAY: DJNZ R7, LOOPDELAY
RET

// 0 TO 2.5 VOLTS
SINEUPHALF: DB 00H, 0DH, 1AH, 27H, 34H, 3FH, 4BH, 55H, 5FH, 67H, 6EH, 74H, 79H, 7CH, 7EH, 7FH

END
